PACKAGECONFIG:append = " opencl "
